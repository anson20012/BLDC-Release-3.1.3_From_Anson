# Keil uVision project bldc_keil.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: PAC5250 Active-Semi
  pack: Active-Semi.PAC52XX.2.0.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bldc_keil +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=1
  c define: KEIL, inline=__INLINE
  c include: .\;..\;..\src;..\src\math;..\src\parameter;..\src\protect;..\src\sensored;..\src\braking;..\src\debug;..\src\sensorless;..\src\speed_cmd;..\src\state_machine;..\src\isr;..\src\ppd;..\src\sim;..\src\uart;..\src\device\PAC522x;..\src\device\PAC525x;..\src\device\PAC523x;..\pac5xxx_sdk\pac5xxx_boot_KEIL;..\pac5xxx_sdk\pac5xxx_drivers;..\pac5xxx_sdk\pac5xxx_peripheral;..\pac5xxx_sdk
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ../src/: version.h include.h config_appliction.h config_board.h config_options.h main.c
  group device
    ../src/device/PAC522x/: PAC522x_app.c PAC522x_app.h PAC522x_init.c
    ../src/device/PAC525x/: PAC525x_app.c PAC525x_app.h PAC525x_init.c
    ../src/device/PAC523x/: PAC523x_app.c PAC523x_app.h PAC523x_init.c
  group protect
    ../src/protect/: motor_protect_check.c motor_protect_check.h
  group sensored
    ../src/sensored/: hall.c hall.h
  group sim
    ../src/sim/: libsim_keil.lib sim_config.c sim_config.h
  group math
    ../src/math/: fix16.c fix16.h pid.c pid.h
  group parameter
    ../src/parameter/: user_parameter.c user_parameter.h
  group isr
    ../src/ISR/: isr_adc.c isr_gpio.c isr_systick.c isr_timerA.c isr_timerB.c isr_timerC.c isr_timerD.c
  group ppd
    ../src/ppd/: ppd_config.h ppd_config.c libppd_keil.lib
  group sensorless
    ../src/sensorless/: bldc_misc_functions.c sensorless.h align_and_go_process.c three_phase_sine_table.c get_zero_cross_point.c
  group braking
    ../src/braking/: braking_control.c braking_control.h
  group debug
    ../src/debug/: debug_dac.c debug_dac.h
  group speed_cmd
    ../src/speed_cmd/: speed_ctr_adc_cmd.c speed_ctr_adc_cmd.h speed_ctr_PPM_cmd.c speed_ctr_PPM_cmd.h
  group uart
    ../src/UART/: uart.c uart.h
  group state_machine
    ../src/state_machine/: control_state_machine.c main_state_machine.c
  group pac5xxx_sdk
    ../pac5xxx_sdk/pac5xxx_drivers/: pac5xxx_driver_adc.h pac5xxx_driver_adc_config.c pac5xxx_driver_adc_emux.c pac5xxx_driver_adc_seq.c pac5xxx_driver_arm.h pac5xxx_driver_arm_sleep.c pac5xxx_driver_config.h pac5xxx_driver_gpio.h pac5xxx_driver_gpio_interrupt.c pac5xxx_driver_gpio_io_enable.c pac5xxx_driver_i2c.h pac5xxx_driver_i2c_config.c pac5xxx_driver_i2c_int.c pac5xxx_driver_i2c_read.c pac5xxx_driver_i2c_write.c pac5xxx_driver_memctl_config.c pac5xxx_driver_memory.h pac5xxx_driver_rtc.h pac5xxx_driver_rtc_clear_if.c pac5xxx_driver_rtc_config.c pac5xxx_driver_rtc_reset.c pac5xxx_driver_socbridge.h pac5xxx_driver_socbridge_config.c pac5xxx_driver_socbridge_config_io.c pac5xxx_driver_socbridge_data.c pac5xxx_driver_spi.h pac5xxx_driver_spi_config_int.c pac5xxx_driver_spi_config_io.c pac5xxx_driver_spi_config_master.c pac5xxx_driver_spi_config_slave.c pac5xxx_driver_system.h pac5xxx_driver_system_ccs_config.c pac5xxx_driver_system_pll_config.c pac5xxx_driver_system_pll_config_mhz.c pac5xxx_driver_tile.h pac5xxx_driver_tile_socbridge.c pac5xxx_driver_tile_socbridge_burst.c pac5xxx_driver_tile_socbridge_config.c pac5xxx_driver_tile_socbridge_validate.c pac5xxx_driver_timer.h pac5xxx_driver_timer_base_config.c pac5xxx_driver_timer_base_int.c pac5xxx_driver_timer_base_int_clear.c pac5xxx_driver_timer_base_int_enable.c pac5xxx_driver_timer_capture_latch_config.c pac5xxx_driver_timer_cctrl_capture_config.c pac5xxx_driver_timer_cctrl_config.c pac5xxx_driver_timer_cctrl_int.c pac5xxx_driver_timer_clear.c pac5xxx_driver_timer_clock_config.c pac5xxx_driver_timer_dtg_config.c pac5xxx_driver_timer_set_period.c pac5xxx_driver_uart.h pac5xxx_driver_uart_config.c pac5xxx_driver_watchdog.h pac5xxx_driver_watchdog_clear_if.c pac5xxx_driver_watchdog_config.c pac5xxx_driver_watchdog_config_clock.c pac5xxx_driver_watchdog_reset.c
    ../pac5xxx_sdk/pac5xxx_peripheral/: pac5xxx_ADC.h pac5xxx_GPIO.h pac5xxx_I2C.h pac5xxx_Memory.h pac5xxx_RTC.h pac5xxx_SocBridge.h pac5xxx_SPI.h pac5xxx_SYS.h pac5xxx_tile_DriverManager.h pac5xxx_tile_PowerManager.h pac5xxx_tile_SignalManager.h pac5xxx_tile_SystemManager.h pac5xxx_Timers.h pac5xxx_UART.h pac5xxx_WDT.h pac52XX.h
    ../pac5xxx_sdk/: pac5xxx_sdk_version.h
    ../pac5xxx_sdk/pac5xxx_boot_KEIL/: startup_pac5xxx_keil.s system_pac5xxx.c system_pac5xxx.h
software components: CMSIS:CORE 4.1.0
